# Keil uVision project InputOutput.uvproj, settings and files
target InputOutput (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: InputOutput
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s InputOutput.c
    C:/Keil_v5/TExaSware/ULTRASONIC SENSOR/: display 1.h display 2.h display 3.h nums on 3 displays.h display 1.c display 2.c display 3.c nums on 3 displays.c
